## boards/shields/pocketboard/Kconfig.defconfig
```kconfig
if SHIELD_POCKETBOARD

config ZMK_KEYBOARD_NAME
    default "Pocketboard"

endif
```
